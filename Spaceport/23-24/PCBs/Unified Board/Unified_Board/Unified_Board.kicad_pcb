# Repository Terrapin-Rocket-Team/SRAD_Avionics

## KiCad design Spaceport/23-24/PCBs/Unified Board/Unified_Board/Unified_Board.kicad_pcb

Board: 4 copper layers, 92.0 x 74.7 mm, 51 parts (1 on the bottom side), 35 nets.

Parts:
ANT1: SGGP.12.A
Alt1: BMP390
BT1: 6.8mm_coin_cell_GPS; BatteryHolder_Keystone_2998_1x6.8mm
BZ1: Buzzer; Adafruit_5V_Buzzer
C1, C2, C7: 100nF; C_0805_2012Metric
C3, C4, C8: 0.1uF; C_0805_2012Metric
C5, C6: 22pF; C_0805_2012Metric
C9: 1.0uF; C_0805_2012Metric
C11: 4.7uF; C_0805_2012Metric
C12: LP_C; C_0805_2012Metric
D1: .5A/40V/420mV; D_SOD-123
D3: GPS_LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: BMP_LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D5: IMU_LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D7: PESD0402; D_0402_1005Metric_Pad0.77x0.64mm_HandSolder
FB1: LP_FerriteBead; L_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5
J1, J7: Screw_Terminal_01x02; TerminalBlock_4Ucon_1x02_P3.50mm_Vertical
J2: Serial2 Breakout; PinHeader_1x04_P2.54mm_Vertical
J3: I2C Breakout; PinHeader_1x04_P2.54mm_Vertical
J4: Serial1 Breakout; PinHeader_1x04_P2.54mm_Vertical
J5: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
J6: Conn_01x09_Pin; PinHeader_1x09_P2.54mm_Vertical
R1, R2: 4.7kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4: 4.7k; R_0805_2012Metric
R5, R6, R7, R8: 10K; R_0805_2012Metric
R9: 3.3kΩ; R_0805_2012Metric
R11, R12, R13, R15: 10kΩ; R_0805_2012Metric
R16: LP_R; R_0805_2012Metric
Teensy4.1: Teensy_4.1
U1: BNO055; LGA-28_5.2x3.8mm_P0.5mm
U2: MAX-M10S; ublox_MAX
Y1: 32.768kHz; Crystal_SMD_MicroCrystal_CC7V-T1A-2Pin_3.2x1.5mm

Connections:
/3.3V: Alt1.1 (VDDIO), Alt1.5 (SDO), Alt1.6 (CSB), Alt1.10 (VDD), C1.1, C2.1, C3.2, C7.2, C8.2, D1.2 (A), J2.1, J3.1, J4.1, J6.1, R1.1, R2.1, R3.2, R4.2, R5.2, R11.2, R12.2, R13.1, Teensy4.1.45 (3.3V), U1.3 (VDD), U1.4 (~BOOT_LOAD_PIN), U1.28 (VDDIO), U2.7 (VCC_IO), U2.8 (VCC)
/BACKUP: BT1.1 (+), C9.1, R9.2, U2.6 (V_BCKP)
/BMP_INT: Alt1.7 (INT), Teensy4.1.28 (PWM)
/Breakout_RX1: J4.2, Teensy4.1.1 (RX1)
/Breakout_RX2: J2.2, Teensy4.1.8 (RX2)
/Breakout_TX1: J4.3, Teensy4.1.2 (TX1)
/Breakout_TX2: J2.3, Teensy4.1.9 (TX2)
/Radio_CS: J6.8, Teensy4.1.11 (CS)
/Radio_INT: J6.4, Teensy4.1.22 (GPIO)
/Radio_MISO: J6.6, Teensy4.1.13 (MISO)
/Radio_MOSI: J6.7, Teensy4.1.12 (MOSI)
/Radio_RST: J6.9, Teensy4.1.23 (GPIO)
/Radio_SCK: J6.5, Teensy4.1.34 (SCK)
/SCL: Alt1.2 (SCK), J3.2, R2.2, R4.1, Teensy4.1.40 (SCL), U1.19 (COM1), U2.17 (SCL)
/SDA: Alt1.4 (SDI), J3.3, R1.2, R3.1, Teensy4.1.39 (SDA), U1.20 (COM0), U2.16 (SDA)
GND: ANT1.2 (GND), ANT1.3 (GND), ANT1.4 (GND), ANT1.5 (GND), ANT1.6 (GND), ANT1.7 (GND), ANT1.8 (GND), ANT1.9 (GND), Alt1.3 (VSS), Alt1.8 (VSS), Alt1.9 (VSS), BT1.2 (-), BZ1.2 (+), C1.2, C2.2, C3.1, C4.2, C5.2, C6.1, C7.1, C8.1, C9.2, C12.2, D3.1 (K), D4.1 (K), D5.1 (K), D7.1 (K), J2.4, J3.4, J4.4, J6.2, R6.1, R7.1, R8.1, Teensy4.1.0 (GND), U1.2 (GND), U1.10 (BL_IND), U1.15 (GNDIO), U1.16 (GNDIO), U1.18 (COM2), U1.25 (GNDIO), U2.1 (GND), U2.10 (GND), U2.12 (GND)
unnamed: ANT1.1 (RF_IN), D7.2 (A), FB1.2, U2.11 (RF_IN)
unnamed: BZ1.1 (-), Teensy4.1.24 (PWM)
unnamed: C12.1, FB1.1, R16.2
unnamed: D1.1 (K), R9.1
unnamed: D3.2 (A), R13.2
unnamed: D4.2 (A), R12.1
unnamed: D5.2 (A), R11.1
unnamed: D6.2 (A), R15.1
unnamed: C11.2, D6.1 (K), J7.2, Teensy4.1.46 (GND)
unnamed: C11.1, J1.1, R15.2, Teensy4.1.47 (Vin)
unnamed: J1.2, J7.1
unnamed: C4.1, U1.9 (CAP)
unnamed: R6.2, U1.17 (COM3)
unnamed: R7.2, U1.6 (PS0)
unnamed: R8.2, U1.5 (PS1)
unnamed: C6.2, U1.27 (XIN32), Y1.2
unnamed: C5.1, U1.26 (XOUT32), Y1.1
unnamed: R5.1, U1.11 (~RESET)
unnamed: R16.1, U2.14 (VCC_RF)

## Commit log

2024-02-29 Setup for ground radios
2024-02-29 Basic phase listener
2024-02-29 Changed baud rate
2024-03-01 Fixed code to use receive() and decode()
2024-03-01 Added fake radio data
2024-03-07 Builds in the STM environment.
    Minor concession: removed sd.restart() try which means the SD card is more likely to fail to init.
2024-03-13 Maybe add back some resiliency to the SD card
2024-04-05 working
2024-04-15 Fixed stage conditions
2024-04-15 change time to dump
2024-04-15 stage fixes and velocity fix
2024-04-19 base
2024-06-13 minor fixes
2024-06-16 working idk
2024-06-17 linear buffer
2024-06-18 small fixes & errors
2024-06-18 rewrite mux w/ single byte packets
2024-06-18 Minor Sensor Fixes
2024-06-19 changed radio freq
